require xl2tpd.inc

SRCREV = "5619e1771048e74b729804e8602f409af0f3faea"

SRC_URI += "file://fix-inline-functions-errors-with-gcc-5.x.patch"
